# Keil uVision project traffic.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: traffic2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: traffic1.c

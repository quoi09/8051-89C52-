# Keil uVision project lich.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lvnkit +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c base_lib.h Calendar_Onkit.h Ds1302.h LED7Seg_OnKit.h ThreeWiresProtocol.h
